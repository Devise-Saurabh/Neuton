# IAR project FordeMCDtest.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMS570LS3137ZWT TexasInstruments TMS570LS3137ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 42
  General.FPU2: 3
  ICCARM.CCDiagSuppress: Pa050,
  ICCARM.CCIncludePath2: 01_Code\APP; 01_Code\RTE; 01_Code\APP\app_shared; 01_Code\DIAG; 01_Code\deMCD\Core\Startup; 01_Code\deMCD\Core\LIB; 01_Code\deMCD\Core\Main; 01_Code\deMCD\Core\OS; 01_Code\deMCD\Core\UC; 01_Code\deMCD\Core\UC\adc; 01_Code\deMCD\Core\UC\can; 01_Code\deMCD\Core\UC\dio; 01_Code\deMCD\Core\UC\pwm; 01_Code\deMCD\Core\UC\spi; 01_Code\deMCD\Core\UC\system; 01_Code\deMCD\Core\UC\timer; 01_Code\deMCD\Core\UC\uart; 01_Code\deMCD\Core\ECU; 01_Code\deMCD\Core\ECU\anlg; 01_Code\deMCD\Core\ECU\com; 01_Code\deMCD\Core\ECU\io; 01_Code\deMCD\Core\ECU\mem; 01_Code\deMCD\Core\ECU\serial; 01_Code\deMCD\Core\ECU\system; 01_Code\APP\app_FaultMgr; 01_Code\deMCD\Core\ECU\wdg; 01_Code\deMCD\Core\UC\wdg; 01_Code\deMCD\Core\ECU\txcp; 01_Code\deMCD\Core\ECU\diag; 01_Code\deMCD\Core\UC\eeprom; 01_Code\deMCD\Core\UC\flash; 01_Code\deMCD\Core\LIB\F021 Flash API\02.01.01\include; 01_Code\deMCD\Core\LIB\F021 Flash API\02.01.01\source; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\anlg; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\com; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\diag; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\io; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\mem; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\mem_int; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\serial; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\system; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\txcp; 01_Code\deMCD_CFG\SiftProbe_deVCU\ECU\wdg; 01_Code\deMCD_CFG\SiftProbe_deVCU\OS; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\adc; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\can; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\dio; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\eeprom; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\flash; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\pwm; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\spi; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\system; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\timer; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\uart; 01_Code\deMCD_CFG\SiftProbe_deVCU\UC\wdg; 01_Code\deMCD\Core\DIAG; 01_Code\deMCD_CFG\SiftProbe_deVCU\DIAG; 01_Code\APP\app_Main1msMgr; 01_Code\APP\app_Main10msMgr; 01_Code\APP\app_Main50msMgr; 01_Code\APP\app_Main100msMgr
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FordeMCDtest.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\TMS570LS3137_flash.icf
  ILINK.IlinkAdditionalLibs: 01_Code\deMCD\Core\LIB\F021 Flash API\02.01.01\F021_API_CortexR4_BE.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    Flash_Debug/Obj/: look1_binlxpw.o
  group APP
    01_Code/APP/: app.c app.h
  group APP/app_FaultMgr
    01_Code/APP/app_FaultMgr/: app_FaultMgr.c app_FaultMgr.h app_FaultMgr_cfg.c app_FaultMgr_cfg.h
  group APP/app_Main100ms
    01_Code/APP/app_Main100msMgr/: app_Main100msMgr.c app_Main100msMgr.h app_Main100msMgr_capi.c app_Main100msMgr_capi.h app_Main100msMgr_data.c app_Main100msMgr_private.h app_Main100msMgr_types.h
  group APP/app_Main10ms
    01_Code/APP/app_Main10msMgr/: app_Main10msMgr.c app_Main10msMgr.h app_Main10msMgr_capi.c app_Main10msMgr_capi.h app_Main10msMgr_data.c app_Main10msMgr_private.h app_Main10msMgr_types.h
  group APP/app_Main1ms
    01_Code/APP/app_Main1msMgr/: app_Main1msMgr.c app_Main1msMgr.h app_Main1msMgr_capi.c app_Main1msMgr_capi.h app_Main1msMgr_data.c app_Main1msMgr_private.h app_Main1msMgr_types.h
  group APP/app_Main50ms
    01_Code/APP/app_Main50msMgr/: app_Main50msMgr.c app_Main50msMgr.h app_Main50msMgr_capi.c app_Main50msMgr_capi.h app_Main50msMgr_data.c app_Main50msMgr_private.h app_Main50msMgr_types.h
  group APP/app_shared
    01_Code/APP/app_shared/: builtin_typeid_types.h can_datatype_ground.c can_message.h div_s32.c div_s32.h Double2MultiWord.c Double2MultiWord.h look1_binlcapw.c look1_binlcapw.h look1_binlcpw.c look1_binlcpw.h look1_binlxpw.c look1_binlxpw.h look2_binlcapw.c look2_binlcapw.h look2_binlxpw.c look2_binlxpw.h multiword_types.h MultiWordXor.c MultiWordXor.h RegentorquePC_1.sldd rt_nonfinite.c rt_nonfinite.h rt_powd_snf.c rt_powd_snf.h rt_remd_snf.c rt_remd_snf.h rt_roundd_snf.c rt_roundd_snf.h rtGetInf.c rtGetInf.h rtGetNaN.c rtGetNaN.h rtw_capi.h rtw_modelmap.h rtw_modelmap_logging.h rtwtypes.h sysran_types.h tmwtypes.h uLong2MultiWord.c uLong2MultiWord.h uMultiWord2Double.c uMultiWord2Double.h zero_crossing_types.h
  group DIAG/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/DIAG/: app_diag_cfg.h
  group DIAG/core
    01_Code/deMCD/Core/DIAG/: app_diag.c app_diag.h app_diag_generic_functions.c app_diag_gf.c app_diag_gf.h
  group ECU
    01_Code/deMCD/Core/ECU/: ecu.c ecu.h
  group ECU/anlg/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/ECU/anlg/: ecu_anlg_cfg.c ecu_anlg_cfg.h
  group ECU/anlg/core
    01_Code/deMCD/Core/ECU/anlg/: ecu_anlg.c ecu_anlg.h
  group ECU/com/cgf
    01_Code/deMCD_CFG/SiftProbe_deVCU/ECU/com/: ecu_com_cfg.c ecu_com_cfg.h ecu_com_cfg_gen.c ecu_com_cfg_gen.h
  group ECU/com/core
    01_Code/deMCD/Core/ECU/com/: ecu_com.c ecu_com.h
  group ECU/diag/cfg
    01_Code/deMCD/Cfg/App/ECU/diag/: ecu_diag_cfg.c ecu_diag_cfg.h
  group ECU/diag/core
    01_Code/deMCD/Core/ECU/diag/: ecu_diag.c ecu_diag.h
  group ECU/io/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/ECU/io/: ecu_io_cfg.c ecu_io_cfg.h
  group ECU/io/core
    01_Code/deMCD/Core/ECU/io/: ecu_io.c ecu_io.h
  group ECU/mem/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/ECU/mem/: ecu_mem_cfg.c ecu_mem_cfg.h
  group ECU/mem/core
    01_Code/deMCD/Core/ECU/mem/: ecu_mem.c ecu_mem.h
  group ECU/serial/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/ECU/serial/: ecu_serial_cfg.c ecu_serial_cfg.h
  group ECU/serial/core
    01_Code/deMCD/Core/ECU/serial/: ecu_serial.c ecu_serial.h
  group ECU/system/cfg
    01_Code/deMCD/Cfg/App/ECU/system/: ecu_system_cfg.c ecu_system_cfg.h
  group ECU/system/core
    01_Code/deMCD/Core/ECU/system/: ecu_system.c ecu_system.h
  group ECU/txcp/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/ECU/txcp/: ecu_txcp_cfg.c ecu_txcp_cfg_gen.h
    01_Code/deMCD/Cfg/App/ECU/txcp/: ecu_txcp_cfg.h
  group ECU/txcp/core
    01_Code/deMCD/Core/ECU/txcp/: ecu_txcp.c ecu_txcp.h
  group ECU/wdg/cfg
    01_Code/deMCD/Cfg/App/ECU/wdg/: ecu_wdg_cfg.c ecu_wdg_cfg.h
  group ECU/wdg/core
    01_Code/deMCD/Core/ECU/wdg/: ecu_wdg.c ecu_wdg.h
  group LIB
    01_Code/deMCD/Core/LIB/: lib_data.c lib_data.h lib_delay.c lib_delay.h lib_types.h
  group LIB/F021 Flash API
    01_Code/deMCD/Core/LIB/F021 Flash API/02.01.01/include/: CGT.IAR.h F021.h
    01_Code/deMCD/Core/LIB/F021 Flash API/02.01.01/source/: Fapi_UserDefinedFunctions.c
  group Main
    01_Code/deMCD/Core/Main/: main.c
  group OS/cfg
    01_Code/deMCD/Cfg/App/OS/: os_cfg.c os_cfg.h os_tasks.c os_tasks.h
  group OS/core
    01_Code/deMCD/Core/OS/: os.c os.h
  group RTE
    01_Code/RTE/: rte.c rte.h rte_app.h rte_tasks.c
  group Startup
    01_Code/deMCD/Core/Startup/: arm_comm.h low_level_init.c tms570ls3137_cstartup.s
  group UC
    01_Code/deMCD/Core/UC/: uc.c uc.h uc_header.h
  group UC/adc/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/adc/: uc_adc_cfg.c uc_adc_cfg.h
  group UC/adc/core
    01_Code/deMCD/Core/UC/adc/: uc_adc.c uc_adc.h
  group UC/can/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/can/: uc_can_cfg.c uc_can_cfg.h
  group UC/can/core
    01_Code/deMCD/Core/UC/can/: uc_can.c uc_can.h
  group UC/dio/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/dio/: uc_dio_cfg.c uc_dio_cfg.h
  group UC/dio/core
    01_Code/deMCD/Core/UC/dio/: uc_dio.c uc_dio.h
  group UC/eeprom/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/eeprom/: uc_eeprom_cfg.c uc_eeprom_cfg.h
  group UC/eeprom/core
    01_Code/deMCD/Core/UC/eeprom/: uc_eeprom.c uc_eeprom.h
  group UC/flash/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/flash/: uc_flash_cfg.c uc_flash_cfg.h
  group UC/flash/core
    01_Code/deMCD/Core/UC/flash/: uc_flash.c uc_flash.h
  group UC/pwm/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/pwm/: uc_pwm_cfg.c uc_pwm_cfg.h
  group UC/pwm/core
    01_Code/deMCD/Core/UC/pwm/: uc_pwm.c uc_pwm.h
  group UC/spi/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/spi/: uc_spi_cfg.c uc_spi_cfg.h
  group UC/spi/core
    01_Code/deMCD/Core/UC/spi/: uc_spi.c uc_spi.h
  group UC/system/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/system/: uc_system_cfg.c uc_system_cfg.h
  group UC/system/core
    01_Code/deMCD/Core/UC/system/: uc_system.c uc_system.h
  group UC/timer/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/timer/: uc_timer_cfg.c uc_timer_cfg.h
  group UC/timer/core
    01_Code/deMCD/Core/UC/timer/: uc_timer.c uc_timer.h
  group UC/uart/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/uart/: uc_uart _cfg.c uc_uart_cfg.h
  group UC/uart/core
    01_Code/deMCD/Core/UC/uart/: uc_uart.c uc_uart.h
  group UC/wdg/cfg
    01_Code/deMCD_CFG/SiftProbe_deVCU/UC/wdg/: uc_wdg_cfg.c uc_wdg_cfg.h
  group UC/wdg/core
    01_Code/deMCD/Core/UC/wdg/: uc_wdg.c uc_wdg.h
